# IAR project freertos_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PM; TARGET_IS_TM4C123_RB1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..; ..\..\..\..; ..\..\..\..\third_party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\third_party\FreeRTOS; ..\..\..\..\third_party\FreeRTOS\Source\include; ..\..\..\..\third_party
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_demo.bin
  ILINK.IlinkOutputFile: freertos_demo.out
  ILINK.IlinkIcfFile: freertos_demo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: SSD2119.c SSD2119.h
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
  group Source
    ../drivers/: buttons.c rgb.c
    ./: freertos_demo.c led_task.c SPI_2_MFRC522.c SPI_2_MFRC522.h startup_ewarm.c switch_task.c
    ../../../../third_party/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../../third_party/FreeRTOS/Source/: list.c queue.c tasks.c
    ../../../../third_party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
    ../../../../utils/: uartstdio.c ustdlib.c
